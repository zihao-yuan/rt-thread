# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ac5)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.5
  cpu: IROM(0x00000000,0x200000) IRAM(0x1FFE0000,0x80000)  IRAM2(0X200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(240000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_DDL_DRIVER, HC32F4A0, __RTTHREAD__, __DEBUG
  c include: ..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\libraries\hc32_drivers;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\hc32f4a0_ddl\drivers\cmsis\Include;..\..\..\components\dfs\dfs_v1\include;board\ports;..\..\..\components\libc\compilers\common\include;..\..\..\components\finsh;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\libraries\hc32f4a0_ddl\drivers\hc32_ll_driver\inc;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\fal\inc;board\config\usb_config;..\..\..\components\libc\posix\ipc;board\config;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;.;board;applications;..\..\..\components\drivers\include;..\libraries\hc32f4a0_ddl\drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\..\..\components\libc\posix\io\poll;..\libraries\hc32_drivers\drv_flash;..\..\..\include;board\ports\fal
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c xtal32_fcm.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c
    ../../../components/drivers/mtd/: mtd_nor.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    board/: board.c board_config.c
    board/ports/: drv_spi_flash.c
    ../libraries/hc32f4a0_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a0.s
    ../libraries/hc32_drivers/: drv_adc.c drv_common.c drv_gpio.c drv_irq.c drv_rtc.c drv_sdio.c drv_spi.c drv_usart.c
    ../libraries/hc32_drivers/drv_flash/: drv_flash_f4.c
  group Fal
    ../../../components/fal/src/: fal.c fal_partition.c fal_flash.c fal_rtt.c
  group FAL
    board/ports/fal/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/hc32f4a0_ddl/drivers/hc32_ll_driver/src/: hc32_ll_clk.c hc32_ll_utility.c hc32_ll_efm.c hc32f4a0_ll_interrupts_share.c hc32_ll_rmu.c hc32_ll_fcg.c hc32_ll_pwc.c hc32_ll_gpio.c hc32_ll_usart.c hc32_ll_sdioc.c hc32_ll_tmr0.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_rtc.c hc32_ll_aos.c hc32_ll_adc.c hc32_ll_dma.c hc32_ll_sram.c hc32_ll_spi.c hc32_ll.c hc32_ll_fcm.c
    ../libraries/hc32f4a0_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
